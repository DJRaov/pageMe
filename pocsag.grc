options:
  parameters:
    author: raov
    generate_options: no_gui
    id: pocsag
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: analog_frequency_modulator_fc_0
  id: analog_frequency_modulator_fc
  parameters:
    sensitivity: '0.736'
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: '6250'
    low_cutoff_freq: '-6250'
    samp_rate: '38400'
    type: fir_filter_ccc
    width: '2000'
    win: window.WIN_HAMMING
  states: {}
- name: band_pass_filter_0_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: '12500'
    low_cutoff_freq: '-12500'
    samp_rate: 2e6
    type: fir_filter_ccc
    width: '45000'
    win: window.WIN_HAMMING
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.75'
    type: complex
  states: {}
- name: mixalot_flexencode_0
  id: mixalot_flexencode
  parameters: {}
  states: {}
- name: network_socket_pdu_0
  id: network_socket_pdu
  parameters:
    host: 127.0.0.1
    mtu: '10000'
    port: '52001'
    type: TCP_SERVER
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '384'
    interp: '20000'
    type: ccc
  states: {}
- name: soapy_hackrf_sink_0
  id: soapy_hackrf_sink
  parameters:
    center_freq: 159.2e6
    samp_rate: 2e6
    type: fc32
    vga: '0'
  states: {}

connections:
- [analog_frequency_modulator_fc_0, '0', band_pass_filter_0, '0']
- [band_pass_filter_0, '0', blocks_multiply_const_vxx_0, '0']
- [band_pass_filter_0_0, '0', soapy_hackrf_sink_0, '0']
- [blocks_char_to_float_0, '0', analog_frequency_modulator_fc_0, '0']
- [blocks_multiply_const_vxx_0, '0', rational_resampler_xxx_0, '0']
- [mixalot_flexencode_0, '0', blocks_char_to_float_0, '0']
- [mixalot_flexencode_0, beeps_output, network_socket_pdu_0, pdus]
- [mixalot_flexencode_0, cmds_out, soapy_hackrf_sink_0, cmd]
- [network_socket_pdu_0, pdus, mixalot_flexencode_0, beeps]
- [rational_resampler_xxx_0, '0', band_pass_filter_0_0, '0']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-215-g9a698313
